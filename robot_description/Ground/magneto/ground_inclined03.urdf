Commit message: midway through gym environment construction

File: robot_description/Ground/magneto/ground_inclined03.urdf (robot description, URDF)
Before this commit: robot ground_skeleton, 4 links, 3 joints
Links:
- link wall_link: geometry collision box size=50.0 50.0 2.3
